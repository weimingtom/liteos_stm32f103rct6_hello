# Keil uVision project helloworld.uvproj, settings and files
target helloworld (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: helloworld +hex
  c flags: Optim=1
  c define: USE_HAL_DRIVER, STM32F103xE, LOS_KERNEL_DEBUG_OUT
  c include: ..\targets\Standard_STM32F103RB_NUCLEO\Inc;..\components\cmsis;..\components\cmsis\1.0;..\components\cmsis\2.0;..\kernel\base\include;..\kernel\include;..\kernel\extended\include;..\targets\Standard_STM32F103RB_NUCLEO\OS_CONFIG;..\arch\arm\arm-m\include;..\arch\arm\arm-m\cortex-m3;..\examples\include;..\targets\Standard_STM32F103RB_NUCLEO\Drivers\STM32F1xx_HAL_Driver\Inc;..\targets\Standard_STM32F103RB_NUCLEO\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\targets\Standard_STM32F103RB_NUCLEO\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group targets_drivers_startup
    ./: startup_stm32f10x_hd.s startup_stm32f103xe.s
    ../targets/Standard_STM32F103RB_NUCLEO/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../targets/Standard_STM32F103RB_NUCLEO/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group targets
    ../targets/Standard_STM32F103RB_NUCLEO/Src/: main.c sys_init.c usart.c
  group components_cmsis
    ../components/cmsis/: cmsis_liteos.c
  group kernel_base_core
    ../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group kernel_base_ipc
    ../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
  group kernel_base_mem_bestfit_little
    ../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
  group kernel_base_mem_membox
    ../kernel/base/mem/membox/: los_membox.c
  group kernel_base_mem_common
    ../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
  group kernel_base_misc
    ../kernel/base/misc/: los_misc.c
  group kernel_base_om
    ../kernel/base/om/: los_err.c
  group kernel_extended_tickless
    ../kernel/extended/tickless/: los_tickless.c
  group kernel
    ../kernel/: los_init.c
  group arch_arm_arm-m
    ../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group arch_arm_arm-m_cortex-m3
    ../arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group examples_api
    ../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group targets_drivers_hal
    ../targets/Standard_STM32F103RB_NUCLEO/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
